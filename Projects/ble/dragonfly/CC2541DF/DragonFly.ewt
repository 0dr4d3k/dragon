<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>CC2541DF-DragonFly</name>
    <toolchain>
      <name>8051</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>C-STAT</name>
      <archiveVersion>1</archiveVersion>
      <data>
        <version>1</version>
        <cstatargs>
          <useExtraArgs>0</useExtraArgs>
          <extraArgs></extraArgs>
          <analyzeTimeout>600</analyzeTimeout>
          <enableParallel>0</enableParallel>
          <parallelThreads>1</parallelThreads>
        </cstatargs>
        <cstatsettings/>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>CC2541DF-DragonFly-OAD-ImgA</name>
    <toolchain>
      <name>8051</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>C-STAT</name>
      <archiveVersion>1</archiveVersion>
      <data>
        <version>1</version>
        <cstatargs>
          <useExtraArgs>0</useExtraArgs>
          <extraArgs></extraArgs>
          <analyzeTimeout>600</analyzeTimeout>
          <enableParallel>0</enableParallel>
          <parallelThreads>1</parallelThreads>
        </cstatargs>
        <cstatsettings/>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>CC2541DF-DragonFly-OAD-ImgB</name>
    <toolchain>
      <name>8051</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>C-STAT</name>
      <archiveVersion>1</archiveVersion>
      <data>
        <version>1</version>
        <cstatargs>
          <useExtraArgs>0</useExtraArgs>
          <extraArgs></extraArgs>
          <analyzeTimeout>600</analyzeTimeout>
          <enableParallel>0</enableParallel>
          <parallelThreads>2</parallelThreads>
        </cstatargs>
        <cstatsettings/>
      </data>
    </settings>
  </configuration>
  <group>
    <name>APP</name>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\Components\hal\target\Cc2541df\ByteBuffer.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\Components\hal\target\Cc2541df\ByteBuffer.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Source\DragonFly-Notes.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Source\DragonFly.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Source\DragonFly.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Source\DragonFly_Gate.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Source\DragonFly_Gate.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Source\DragonFly_Main.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Source\DragonFly_Net_Core.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Source\DragonFly_Net_Core.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Source\DragonFly_Oad.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Source\DragonFly_Oad.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\Components\hal\target\Cc2541df\hal_humi.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\Components\hal\target\Cc2541df\hal_humi.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Source\OSAL_DragonFly.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Source\serialInterface.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Source\serialInterface.h</name>
    </file>
  </group>
  <group>
    <name>HAL</name>
    <group>
      <name>Board</name>
      <group>
        <name>Common</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\Components\hal\include\hal_defs.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\Components\hal\target\Cc2541df\hal_mcu.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\Components\hal\target\Cc2541df\hal_types.h</name>
        </file>
      </group>
      <group>
        <name>Include</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\Components\hal\target\Cc2541df\hal_adc.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\Components\hal\target\Cc2541df\hal_aes.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\Components\hal\include\hal_assert.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\Components\hal\target\Cc2541df\hal_crc.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\Components\hal\target\Cc2541df\hal_debug.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\Components\hal\target\Cc2541df\hal_dma.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\Components\hal\target\Cc2541df\hal_drivers.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\Components\hal\include\hal_flash.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\Components\hal\target\Cc2541df\hal_i2c.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\Components\hal\target\Cc2541df\hal_sensor.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\Components\hal\include\hal_sleep.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\Components\hal\target\Cc2541df\hal_suart.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\Components\hal\include\hal_timer.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\Components\hal\target\Cc2541df\uart\hal_uart.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\Components\hal\target\Cc2541df\ioCC254x_bitdef.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\Components\hal\target\Cc2541df\OnBoard.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\Components\services\saddr\saddr.h</name>
        </file>
      </group>
      <group>
        <name>OnBoard</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\Components\hal\target\Cc2541df\hal_adc.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\Components\hal\target\Cc2541df\hal_aes.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\Components\hal\target\Cc2541df\hal_assert.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\Components\hal\target\Cc2541df\hal_crc.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\Components\hal\target\Cc2541df\hal_debug.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\Components\hal\target\Cc2541df\hal_dma.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\Components\hal\target\Cc2541df\hal_drivers.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\Components\hal\target\Cc2541df\hal_flash.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\Components\hal\target\Cc2541df\hal_i2c.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\Components\hal\target\Cc2541df\hal_interrupt.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\Components\hal\target\Cc2541df\hal_sensor.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\Components\hal\target\Cc2541df\hal_sleep.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\Components\hal\target\Cc2541df\hal_startup.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\Components\hal\target\Cc2541df\hal_suart.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\Components\hal\target\Cc2541df\uart\hal_uart.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\Components\hal\target\Cc2541df\OnBoard.c</name>
        </file>
      </group>
    </group>
    <group>
      <name>Config</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\Components\hal\include\hal_board.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\Components\hal\target\Cc2541df\hal_board_cfg.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\Components\hal\target\Cc2541df\hal_board_cfg_actuator.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\Components\hal\target\Cc2541df\hal_board_cfg_air.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\Components\hal\target\Cc2541df\hal_board_cfg_common.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\Components\hal\target\Cc2541df\hal_board_cfg_gateway.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\Components\hal\target\Cc2541df\hal_board_cfg_light.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\Components\hal\target\Cc2541df\hal_board_cfg_minimal.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\Components\hal\target\Cc2541df\hal_board_cfg_plants.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\Components\hal\target\Cc2541df\hal_board_cfg_thermostat.h</name>
      </file>
    </group>
    <group>
      <name>Target</name>
      <group>
        <name>Drivers</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\Components\hal\target\Cc2541df\hal_acc.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\Components\hal\target\Cc2541df\hal_air.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\Components\hal\target\Cc2541df\hal_buzzer.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\Components\hal\target\Cc2541df\hal_keys.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\Components\hal\target\Cc2541df\hal_led.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\Components\hal\target\Cc2541df\hal_lux.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\Components\hal\target\Cc2541df\hal_mag.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\Components\hal\target\Cc2541df\hal_pir.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\Components\hal\target\Cc2541df\hal_qi.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\Components\hal\target\Cc2541df\hal_timer.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\Components\hal\target\Cc2541df\hal_uvi.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\Components\hal\target\Cc2541df\hal_weather.c</name>
        </file>
      </group>
      <group>
        <name>Includes</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\Components\hal\target\Cc2541df\hal_acc.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\Components\hal\target\Cc2541df\hal_air.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\Components\hal\target\Cc2541df\hal_buzzer.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\Components\hal\include\hal_key.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\Components\hal\target\Cc2541df\hal_keys.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\Components\hal\include\hal_led.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\Components\hal\target\Cc2541df\hal_lux.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\Components\hal\target\Cc2541df\hal_mag.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\Components\hal\target\Cc2541df\hal_pir.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\Components\hal\target\Cc2541df\hal_qi.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\Components\hal\target\Cc2541df\hal_uvi.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\Components\hal\target\Cc2541df\hal_weather.h</name>
        </file>
      </group>
    </group>
  </group>
  <group>
    <name>HCI</name>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\Components\ble\include\hci.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\Components\ble\hci\hci_data.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\Components\ble\hci\hci_event.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Include\hci_ext.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\Components\ble\hci\hci_tl.h</name>
    </file>
  </group>
  <group>
    <name>LIB</name>
    <file>
      <name>$PROJ_DIR$\..\..\Libraries\CC2541DB\bin\CC2541_BLE.lib</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Libraries\CC2541DB\bin\CC2541_BLE_bcast.lib</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Libraries\CC2541DB\bin\CC2541_BLE_bcast_cent.lib</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Libraries\CC2541DB\bin\CC2541_BLE_bcast_observ.lib</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Libraries\CC2541DB\bin\CC2541_BLE_cent.lib</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Libraries\CC2541DB\bin\CC2541_BLE_observ.lib</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Libraries\CC2541DB\bin\CC2541_BLE_peri.lib</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Libraries\CC2541DB\bin\CC2541_BLE_peri_observ.lib</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Libraries\Common\bin\CC254x_BLE_HCI_TL_bcast.lib</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Libraries\Common\bin\CC254x_BLE_HCI_TL_bcast_cent.lib</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Libraries\Common\bin\CC254x_BLE_HCI_TL_bcast_observ.lib</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Libraries\Common\bin\CC254x_BLE_HCI_TL_cent.lib</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Libraries\Common\bin\CC254x_BLE_HCI_TL_Full.lib</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Libraries\Common\bin\CC254x_BLE_HCI_TL_None.lib</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Libraries\Common\bin\CC254x_BLE_HCI_TL_observ.lib</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Libraries\Common\bin\CC254x_BLE_HCI_TL_peri.lib</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Libraries\Common\bin\CC254x_BLE_HCI_TL_peri_observ.lib</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Libraries\Common\bin\CC254x_BLE_HCI_TL_PTM.lib</name>
    </file>
  </group>
  <group>
    <name>NPI</name>
    <file>
      <name>$PROJ_DIR$\..\..\common\npi\npi_np\npi.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\common\npi\npi_np\npi.h</name>
    </file>
  </group>
  <group>
    <name>OSAL</name>
    <group>
      <name>Includes</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\Components\ble\include\bcomdef.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\Components\osal\include\OSAL.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\Components\osal\include\osal_bufmgr.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\Components\osal\include\osal_cbtimer.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\Components\osal\include\OSAL_Clock.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\Components\osal\include\OSAL_Memory.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\Components\osal\include\OSAL_Nv.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\Components\osal\include\OSAL_PwrMgr.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\Components\osal\include\osal_snv.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\Components\osal\include\OSAL_Tasks.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\Components\osal\include\OSAL_Timers.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\Components\osal\include\ZComDef.h</name>
      </file>
    </group>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\Components\osal\common\OSAL.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\Components\osal\common\osal_bufmgr.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\Components\osal\common\osal_cbtimer.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\Components\osal\common\OSAL_ClockBLE.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\Components\osal\common\OSAL_Memory.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\Components\osal\common\OSAL_PwrMgr.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\Components\osal\mcu\cc2540\osal_snv.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\Components\osal\common\OSAL_Timers.c</name>
    </file>
  </group>
  <group>
    <name>PROFILES</name>
    <group>
      <name>Includes</name>
      <file>
        <name>$PROJ_DIR$\..\..\Profiles\DragonflyProfile\accservice.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Profiles\DragonflyProfile\airservice.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Profiles\DragonflyProfile\alarmservice.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Profiles\DragonflyProfile\analogservice.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Profiles\Batt\CC254x\battservice.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Profiles\DragonflyProfile\ccservice.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Profiles\Roles\CC254x\central.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Profiles\DragonflyProfile\dataloggerservice.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Profiles\DragonflyProfile\devinfoservice-df.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Profiles\DragonflyProfile\df_util.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Profiles\DragonflyProfile\digitalservice.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Profiles\DragonflyProfile\dl.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Profiles\DragonflyProfile\dl_target.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Profiles\DragonflyProfile\eventservice.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Profiles\Roles\gapbondmgr.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Include\gapgattserver.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Profiles\DragonflyProfile\gateservice.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Include\gatt_profile_uuid.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Include\gattservapp.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Profiles\HIDDev\CC254x\hiddev.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Profiles\DragonflyProfile\intempservice.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Profiles\DragonflyProfile\ioservice.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Profiles\DragonflyProfile\luxometerservice.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Profiles\DragonflyProfile\magnetometerservice.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Profiles\OAD\oad.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Profiles\OAD\oad_target.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Profiles\Roles\peripheral.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Profiles\DragonflyProfile\registerservice.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Profiles\Keys\simplekeys.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Profiles\DragonflyProfile\testservice.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Profiles\DragonflyProfile\uviservice.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Profiles\DragonflyProfile\weatherservice.h</name>
      </file>
    </group>
    <file>
      <name>$PROJ_DIR$\..\..\Profiles\DragonflyProfile\accservice.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Profiles\DragonflyProfile\airservice.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Profiles\DragonflyProfile\alarmservice.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Profiles\DragonflyProfile\analogservice.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Profiles\Batt\CC254x\battservice.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Profiles\DragonflyProfile\ccservice.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Profiles\Roles\CC254x\central.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Profiles\DragonflyProfile\dataloggerservice.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Profiles\DragonflyProfile\devinfoservice-df.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Profiles\DragonflyProfile\df_util.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Profiles\DragonflyProfile\digitalservice.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Profiles\DragonflyProfile\dl_target.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Profiles\DragonflyProfile\eventservice.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Profiles\Roles\gap.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Profiles\Roles\gapbondmgr.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Profiles\DragonflyProfile\gateservice.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\Components\ble\host\gatt_uuid.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Profiles\GATT\gattservapp_util.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Profiles\HIDDev\CC254x\hiddev.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Profiles\DragonflyProfile\intempservice.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Profiles\DragonflyProfile\ioservice.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Profiles\DragonflyProfile\luxometerservice.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Profiles\DragonflyProfile\magnetometerservice.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Profiles\OAD\oad_target.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Profiles\Roles\CC254x\peripheral.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Profiles\DragonflyProfile\registerservice.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Profiles\Keys\CC254x\simplekeys.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Profiles\DragonflyProfile\testservice.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Profiles\DragonflyProfile\uviservice.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Profiles\DragonflyProfile\weatherservice.c</name>
    </file>
  </group>
  <group>
    <name>TOOLS</name>
    <file>
      <name>$PROJ_DIR$\..\..\config\buildComponents.cfg</name>
    </file>
    <file>
      <name>$PROJ_DIR$\buildConfig.cfg</name>
    </file>
  </group>
</project>


