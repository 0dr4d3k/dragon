# IAR project DragonFly.ewp, settings and files
configuration CC2541DF-DragonFly (8051)
  General.OGChipSelectMenu: CC2541F256 CC2541F256
  ICC8051.CCDefines: xFEATURE_OAD_BIM; xHAL_IMAGE_A; xFEATURE_OAD; xOAD_KEEP_NV_PAGES; xOAD_IMAGE_VERSION=6; INT_HEAP_LEN=3072; HALNODEBUG; OSAL_CBTIMER_NUM_TASKS=1; HAL_AES_DMA=TRUE; HAL_DMA=TRUE; POWER_SAVING; HAL_LCD=FALSE; HAL_LED=TRUE; HAL_KEY=TRUE; HAL_I2C=TRUE; HAL_ADC=TRUE; FEATURE_TEST; USER_DESCRIPTION; xPLUS_BROADCASTER; xFEATURE_REGISTER_SERVICE; BATTERY_SERVICE
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: ..\..\common; ..\..\include; ..\..\..\..\Components\hal\include; ..\..\..\..\Components\hal\target\CC2541DF; ..\..\..\..\Components\osal\include; ..\..\..\..\Components\services\saddr; ..\..\..\..\Components\ble\include; ..\..\..\..\Components\ble\controller\CC254x\phy; ..\..\..\..\Components\ble\controller\CC254x\include; ..\..\..\..\Components\ble\hci; ..\..\..\..\Components\ble\host; ..\..\..\..\Components\ble\ROM; ..\..\common\cc2540; ..\..\common\npi\npi_np; ..\..\Profiles\Roles; ..\..\Profiles\Roles\cc254x; ..\..\Profiles\DragonflyProfile; ..\..\Profiles\Keys; ..\..\Profiles\Batt\cc254x; ..\..\Profiles\HIDDev\cc254x; ..\..\Profiles\DevInfo; ..\..\Profiles\ScanParam; ..\..\Profiles\ScanParam\cc254x; ..\..\Profiles\Oad
  ICC8051.CCOptLevel: 0
  ICC8051.CCOptStrategy: 0
  ICC8051.IccLang: 0
  XLINK.XclFile: ..\..\common\cc2540\ti_51ew_cc2540b.xcl
configuration CC2541DF-DragonFly-OAD-ImgA (8051)
  as the first configuration, except:
  ICC8051.CCIncludePath2: ..\..\common; ..\..\include; ..\..\..\..\Components\hal\include; ..\..\..\..\Components\hal\target\CC2541df; ..\..\..\..\Components\hal\target\CC2541df\uart; ..\..\..\..\Components\osal\include; ..\..\..\..\Components\services\saddr; ..\..\..\..\Components\ble\include; ..\..\..\..\Components\ble\controller\CC254x\phy; ..\..\..\..\Components\ble\controller\CC254x\include; ..\..\..\..\Components\ble\hci; ..\..\..\..\Components\ble\host; ..\..\..\..\Components\ble\ROM; ..\..\common\cc2540; ..\..\common\npi\npi_np; ..\..\Profiles\Roles; ..\..\Profiles\Roles\cc254x; ..\..\Profiles\DragonflyProfile; ..\..\Profiles\Keys; ..\..\Profiles\Batt\cc254x; ..\..\Profiles\HIDDev\cc254x; ..\..\Profiles\DevInfo; ..\..\Profiles\ScanParam; ..\..\Profiles\ScanParam\cc254x; ..\..\Profiles\Oad
  ICC8051.CCOptLevel: 3
  ICC8051.CCOptStrategy: 1
  postbuild: ..\..\common\cc2540\Dragonfly-PostBuild.bat
  XLINK.XclFile: ..\..\common\cc2540\df_cc254x_f256_imgA_a100K.xcl
configuration CC2541DF-DragonFly-OAD-ImgB (8051)
  as the first configuration, except:
  ICC8051.CCIncludePath2: as above
  ICC8051.CCOptLevel: 3
  ICC8051.CCOptStrategy: 1
  postbuild: ..\..\common\cc2540\Dragonfly-PostBuild.bat
  XLINK.XclFile: ..\..\common\cc2540\df_cc254x_f256_imgB_a148K.xcl
  group APP
    ../../../../Components/hal/target/Cc2541df/: ByteBuffer.c ByteBuffer.h hal_humi.c hal_humi.h
    ../Source/: DragonFly-Notes.c DragonFly.c dragonfly.h DragonFly_Gate.c DragonFly_Gate.h DragonFly_Main.c DragonFly_Net_Core.c DragonFly_Net_Core.h DragonFly_Oad.c DragonFly_Oad.h OSAL_DragonFly.c serialInterface.c serialInterface.h
  group HAL/Board/Common
    ../../../../Components/hal/include/: hal_defs.h
    ../../../../Components/hal/target/Cc2541df/: hal_mcu.h hal_types.h
  group HAL/Board/Include
    ../../../../Components/hal/target/Cc2541df/: hal_adc.h hal_aes.h hal_crc.h hal_debug.h hal_dma.h hal_drivers.h hal_i2c.h hal_sensor.h hal_suart.h ioCC254x_bitdef.h OnBoard.h
    ../../../../Components/hal/include/: hal_assert.h hal_flash.h hal_sleep.h hal_timer.h
    ../../../../Components/hal/target/Cc2541df/uart/: hal_uart.h
    ../../../../Components/services/saddr/: saddr.h
  group HAL/Board/OnBoard
    ../../../../Components/hal/target/Cc2541df/: hal_adc.c hal_aes.c hal_assert.c hal_crc.c hal_debug.c hal_dma.c hal_drivers.c hal_flash.c hal_i2c.c hal_interrupt.c hal_sensor.c hal_sleep.c hal_startup.c hal_suart.c OnBoard.c
    ../../../../Components/hal/target/Cc2541df/uart/: hal_uart.c
  group HAL/Config
    ../../../../Components/hal/include/: hal_board.h
    ../../../../Components/hal/target/Cc2541df/: hal_board_cfg.h hal_board_cfg_actuator.h hal_board_cfg_air.h hal_board_cfg_common.h hal_board_cfg_gateway.h hal_board_cfg_light.h hal_board_cfg_minimal.h hal_board_cfg_plants.h hal_board_cfg_thermostat.h
  group HAL/Target/Drivers
    ../../../../Components/hal/target/Cc2541df/: hal_acc.c hal_air.c hal_buzzer.c hal_keys.c hal_led.c hal_lux.c hal_mag.c hal_pir.c hal_qi.c hal_timer.c hal_uvi.c hal_weather.c
  group HAL/Target/Includes
    ../../../../Components/hal/target/Cc2541df/: hal_acc.h hal_air.h hal_buzzer.h hal_keys.h hal_lux.h hal_mag.h hal_pir.h hal_qi.h hal_uvi.h hal_weather.h
    ../../../../Components/hal/include/: hal_key.h hal_led.h
  group HCI
    ../../../../Components/ble/include/: hci.h
    ../../../../Components/ble/hci/: hci_data.h hci_event.h hci_tl.h
    ../../Include/: hci_ext.h
  group LIB
    ../../Libraries/CC2541DB/bin/: CC2541_BLE.lib CC2541_BLE_bcast.lib CC2541_BLE_bcast_cent.lib CC2541_BLE_bcast_observ.lib CC2541_BLE_cent.lib CC2541_BLE_observ.lib CC2541_BLE_peri.lib CC2541_BLE_peri_observ.lib
    ../../Libraries/Common/bin/: CC254x_BLE_HCI_TL_bcast.lib CC254x_BLE_HCI_TL_bcast_cent.lib CC254x_BLE_HCI_TL_bcast_observ.lib CC254x_BLE_HCI_TL_cent.lib CC254x_BLE_HCI_TL_Full.lib CC254x_BLE_HCI_TL_None.lib CC254x_BLE_HCI_TL_observ.lib CC254x_BLE_HCI_TL_peri.lib CC254x_BLE_HCI_TL_peri_observ.lib CC254x_BLE_HCI_TL_PTM.lib
  group NPI
    ../../common/npi/npi_np/: npi.c npi.h
  group OSAL
    ../../../../Components/osal/common/: OSAL.c osal_bufmgr.c osal_cbtimer.c OSAL_ClockBLE.c OSAL_Memory.c OSAL_PwrMgr.c OSAL_Timers.c
    ../../../../Components/osal/mcu/cc2540/: osal_snv.c
  group OSAL/Includes
    ../../../../Components/ble/include/: bcomdef.h
    ../../../../Components/osal/include/: OSAL.h osal_bufmgr.h osal_cbtimer.h OSAL_Clock.h OSAL_Memory.h OSAL_Nv.h OSAL_PwrMgr.h osal_snv.h OSAL_Tasks.h OSAL_Timers.h ZComDef.h
  group PROFILES
    ../../Profiles/DragonflyProfile/: accservice.c airservice.c alarmservice.c analogservice.c ccservice.c dataloggerservice.c devinfoservice-df.c df_util.c digitalservice.c dl_target.c eventservice.c gateservice.c intempservice.c ioservice.c luxometerservice.c magnetometerservice.c registerservice.c testservice.c uviservice.c weatherservice.c
    ../../Profiles/Batt/CC254x/: battservice.c
    ../../Profiles/Roles/CC254x/: central.c peripheral.c
    ../../Profiles/Roles/: gap.c gapbondmgr.c
    ../../../../Components/ble/host/: gatt_uuid.c
    ../../Profiles/GATT/: gattservapp_util.c
    ../../Profiles/HIDDev/CC254x/: hiddev.c
    ../../Profiles/OAD/: oad_target.c
    ../../Profiles/Keys/CC254x/: simplekeys.c
  group PROFILES/Includes
    ../../Profiles/DragonflyProfile/: accservice.h airservice.h alarmservice.h analogservice.h ccservice.h dataloggerservice.h devinfoservice-df.h df_util.h digitalservice.h dl.h dl_target.h eventservice.h gateservice.h intempservice.h ioservice.h luxometerservice.h magnetometerservice.h registerservice.h testservice.h uviservice.h weatherservice.h
    ../../Profiles/Batt/CC254x/: battservice.h
    ../../Profiles/Roles/CC254x/: central.h
    ../../Profiles/Roles/: gapbondmgr.h peripheral.h
    ../../Include/: gapgattserver.h gatt_profile_uuid.h gattservapp.h
    ../../Profiles/HIDDev/CC254x/: hiddev.h
    ../../Profiles/OAD/: oad.h oad_target.h
    ../../Profiles/Keys/: simplekeys.h
  group TOOLS
    ../../config/: buildComponents.cfg
    ./: buildConfig.cfg
