# IAR project HIDAdvRemote.ewp, settings and files
configuration CC2541 AdvRemote (8051, debug)
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\CC2540F256.i51
  ICC8051.CCDefines: INT_HEAP_LEN=2048; HALNODEBUG; OSAL_CBTIMER_NUM_TASKS=1; POWER_SAVING; CELL_BATTERY; HCI_DISABLE_UART; xDEBUG; HCI_SINGLE_CHIP; GAP_PRIVACY_RECONNECT; TEST_MODE; HCI_DISABLE_PTM; HAL_BUZZER=TRUE; HAL_KEY=TRUE; HAL_LCD=FALSE; HAL_LED=FALSE; HAL_MOTION=TRUE; HAL_AES_DMA=TRUE; HAL_DMA=TRUE; HAL_BATMON=TRUE; HAL_ADC=TRUE; HAL_TIMER=FALSE; HAL_UART=FALSE; HAL_I2C=TRUE; XOSC32K_INSTALLED=TRUE; GAP_CHAR_CFG_MAX=8; HAL_I2C_MASTER=TRUE
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: ..\..\common; ..\..\include; ..\..\..\..\Components\hal\include; ..\..\..\..\Components\hal\target\CC2540EB; ..\..\..\..\Components\hal\target\CC2541ARC; ..\..\..\..\Components\osal\include; ..\..\..\..\Components\services\saddr; ..\..\..\..\Components\ble\include; ..\..\..\..\Components\ble\controller\phy; ..\..\..\..\Components\ble\controller\include; ..\..\..\..\Components\ble\hci; ..\..\..\..\Components\ble\host; ..\..\common\cc2540; ..\..\Profiles\Roles; ..\..\Profiles\HidDevKbM; ..\..\Profiles\HidDev; ..\..\Profiles\DevInfo; ..\..\Profiles\Batt; ..\..\Profiles\ScanParam; ..\..\Profiles\OAD
  ICC8051.CCOptLevel: 3
  ICC8051.CCOptStrategy: 2
  ICC8051.IccLang: 0
  XLINK.XclFile: ..\..\common\cc2540\ti_51ew_cc2540b.xcl
configuration CC2541 AdvRemote ImgB (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: FEATURE_OAD_BIM; HAL_IMAGE_B; FEATURE_OAD; OAD_KEEP_NV_PAGES; INT_HEAP_LEN=3072; HALNODEBUG; OSAL_CBTIMER_NUM_TASKS=1; HAL_AES_DMA=TRUE; HAL_DMA=TRUE; POWER_SAVING; xPLUS_BROADCASTER; HAL_LCD=TRUE; HAL_LED=FALSE; HAL_KEY=FALSE; HAL_ADC=FALSE; OAD_IMG_A_PAGE=1; OAD_IMG_A_AREA=47; OAD_IMG_B_PAGE=8; OAD_IMG_B_AREA=(124 - OAD_IMG_A_AREA); HAL_BUZZER=TRUE; HAL_KEY=TRUE; HAL_LCD=FALSE; HAL_LED=FALSE; HAL_MOTION=TRUE; HAL_AES_DMA=TRUE; HAL_DMA=TRUE; HAL_BATMON=TRUE; HAL_ADC=TRUE; HAL_TIMER=FALSE; HAL_UART=FALSE; HAL_I2C=TRUE; XOSC32K_INSTALLED=TRUE; GAP_CHAR_CFG_MAX=8; HAL_I2C_MASTER=TRUE
  ICC8051.CCOptStrategy: 1
  postbuild: "..\..\common\cc2540\cc254x_ubl_pp.bat" "$PROJ_DIR$" "ProdUBL" "CC2541 AdvRemote ImgB\Exe\HidAdvRemoteImgB"
  XLINK.XclFile: ..\Source\cc254x_f256_imgB_Large.xcl
  group APP
    ../Source/: hidAdvRemote.c hidAdvRemote.h hidAdvRemote_main.c OSAL_hidAdvRemote.c
  group HAL/Common
    ../../../../Components/hal/target/CC2541ARC/: hal_drivers.c
  group HAL/Include
    ../../../../Components/hal/include/: hal_adc.h hal_assert.h hal_board.h hal_ccm.h hal_defs.h hal_flash.h hal_key.h hal_lcd.h hal_led.h hal_rpc.h hal_sleep.h hal_timer.h hal_uart.h
    ../../../../Components/hal/target/CC2541ARC/: hal_drivers.h
  group HAL/Target/CC2540EB/Config
    ../../../../Components/hal/target/CC2540EB/: hal_board_cfg.h
  group HAL/Target/CC2540EB/Drivers
    ../../../../Components/hal/target/CC2541ARC/: hal_accel.c hal_accel.h hal_buzzer.c hal_buzzer.h hal_gyro.c hal_gyro.h hal_i2c.c hal_i2c.h hal_key.c hal_motion.c HAL_motion.h hal_sleep.c
    ../../../../Components/hal/target/CC2540EB/: hal_adc.c hal_aes.c hal_crc.c hal_dma.c hal_flash.c hal_led.c hal_startup.c hal_uart.c
  group HAL/Target/CC2540EB/Drivers/LIB
    ../../../../Components/hal/target/CC2541ARC/: AIR_MOTION_LIB_3G3A-Banked.r51
  group HAL/Target/CC2540EB/Includes
    ../../../../Components/hal/target/CC2540EB/: hal_aes.h hal_dma.h hal_mcu.h hal_types.h
  group INCLUDE
    ../../../../Components/ble/include/: att.h gap.h gatt.h gatt_uuid.h hci.h l2cap.h sm.h
    ../../../../Components/ble/host/: linkdb.h
    ../../../../Components/ble/controller/include/: ll.h phy.h
  group LIB
    ../../Libraries/CC2541DB/bin/: CC2541_BLE_peri.lib
    ../../Libraries/Common/bin/: CC254x_BLE_HCI_TL_None.lib
  group NPI
    ../../common/npi/npi_np/: npi.c npi.h
  group OSAL
    ../../../../Components/ble/include/: bcomdef.h
    ../../../../Components/osal/common/: OSAL.c osal_bufmgr.c osal_cbtimer.c OSAL_ClockBLE.c OSAL_Memory.c OSAL_PwrMgr.c OSAL_Timers.c
    ../../../../Components/osal/mcu/cc2540/: osal_snv.c
  group PROFILES
    ../../Profiles/Batt/: battservice.c battservice.h
    ../../Profiles/DevInfo/: devinfoservice.c devinfoservice.h
    ../../Profiles/Roles/: gap.c gapbondmgr.c gapbondmgr.h peripheral.c peripheral.h
    ../../Include/: gapgattserver.h gattservapp.h
    ../../../../Components/ble/host/: gatt_uuid.c
    ../../Profiles/HIDDev/: hiddev.c hiddev.h
    ../../Profiles/HIDDevKbM/: hidkbmservice.c hidkbmservice.h
    ../../Profiles/OAD/: oad.h oad_target.c oad_target.h
    ../../Profiles/ScanParam/: scanparamservice.c scanparamservice.h
  group TOOLS
    ../../config/: buildComponents.cfg
    ./: buildConfig.cfg
    ../../common/cc2540/: lnk51ew_cc2530b_banked_rom_data.xcl lnk_banked_rom_data.xcl OnBoard.c OnBoard.h
