# IAR project io_in_cc254x.ewp, settings and files
configuration Debug (8051, debug)
  General.OGChipSelectMenu: CC2543F32 CC2543F32
  ICC8051.CCDefines: chip=2541
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: source; source\components
  ICC8051.CCOptLevel: 0
  ICC8051.CCOptStrategy: 0
  ICC8051.IccLang: 0
  XLINK.XclFile: lnk0t.xcl
  group (top)
    source/: io_in.c
