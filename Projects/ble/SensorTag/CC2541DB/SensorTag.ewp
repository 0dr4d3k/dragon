# IAR project SensorTag.ewp, settings and files
configuration CC2541DK-Sensor (8051)
  General.OGChipSelectMenu: CC2541F256 CC2541F256
  ICC8051.CCDefines: xGATT_TI_UUID_128_BIT; INT_HEAP_LEN=3072; HALNODEBUG; OSAL_CBTIMER_NUM_TASKS=1; HAL_AES_DMA=TRUE; HAL_DMA=TRUE; POWER_SAVING; HAL_LCD=FALSE; HAL_LED=TRUE; HAL_KEY=TRUE; HAL_I2C=TRUE; HAL_ADC=FALSE
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: ..\..\common; ..\..\include; ..\..\..\..\Components\hal\include; ..\..\..\..\Components\hal\target\CC2541ST; ..\..\..\..\Components\osal\include; ..\..\..\..\Components\services\saddr; ..\..\..\..\Components\ble\include; ..\..\..\..\Components\ble\controller\CC254x\phy; ..\..\..\..\Components\ble\controller\CC254x\include; ..\..\..\..\Components\ble\hci; ..\..\..\..\Components\ble\host; ..\..\..\..\Components\ble\ROM; ..\..\common\cc2540; ..\..\common\npi\npi_np; ..\..\Profiles\Roles; ..\..\Profiles\Roles\cc254x; ..\..\Profiles\SensorProfile\cc254x; ..\..\Profiles\Keys; ..\..\Profiles\DevInfo
  ICC8051.CCOptLevel: 0
  ICC8051.CCOptStrategy: 1
  ICC8051.IccLang: 0
  XLINK.XclFile: ..\..\common\cc2540\ti_51ew_cc2540b.xcl
configuration CC2541DK-Sensor-OAD-ImgA (8051)
  as the first configuration, except:
  ICC8051.CCDefines: FEATURE_OAD_BIM; HAL_IMAGE_A; FEATURE_OAD; OAD_KEEP_NV_PAGES; INT_HEAP_LEN=3072; HALNODEBUG; OSAL_CBTIMER_NUM_TASKS=1; HAL_AES_DMA=TRUE; HAL_DMA=TRUE; POWER_SAVING; HAL_LCD=FALSE; HAL_LED=TRUE; HAL_KEY=TRUE; HAL_I2C=TRUE; HAL_ADC=FALSE; OAD_IMAGE_VERSION=6
  ICC8051.CCIncludePath2: ..\..\common; ..\..\include; ..\..\..\..\Components\hal\include; ..\..\..\..\Components\hal\target\CC2541ST; ..\..\..\..\Components\osal\include; ..\..\..\..\Components\services\saddr; ..\..\..\..\Components\ble\include; ..\..\..\..\Components\ble\controller\CC254x\phy; ..\..\..\..\Components\ble\controller\CC254x\include; ..\..\..\..\Components\ble\hci; ..\..\..\..\Components\ble\host; ..\..\..\..\Components\ble\ROM; ..\..\common\cc2540; ..\..\common\npi\npi_np; ..\..\Profiles\Roles; ..\..\Profiles\Roles\cc254x; ..\..\Profiles\SensorProfile\cc254x; ..\..\Profiles\Keys; ..\..\Profiles\DevInfo; ..\..\Profiles\Oad
  ICC8051.CCOptLevel: 3
  postbuild: "..\..\common\cc2540\cc254x_ubl_pp.bat" "$PROJ_DIR$" "ProdUBL" "CC2541DK-Sensor-OAD-ImgA\Exe\SensorTag.sim"
  XLINK.XclFile: ..\..\common\cc2540\cc254x_f256_imgA.xcl
configuration CC2541DK-Sensor-OAD-ImgB (8051)
  as the first configuration, except:
  ICC8051.CCDefines: FEATURE_OAD_BIM; HAL_IMAGE_B; FEATURE_OAD; OAD_KEEP_NV_PAGES; INT_HEAP_LEN=3072; HALNODEBUG; OSAL_CBTIMER_NUM_TASKS=1; HAL_AES_DMA=TRUE; HAL_DMA=TRUE; POWER_SAVING; HAL_LCD=FALSE; HAL_LED=TRUE; HAL_KEY=TRUE; HAL_I2C=TRUE; HAL_ADC=FALSE; OAD_IMAGE_VERSION=6
  ICC8051.CCIncludePath2: as above
  ICC8051.CCOptLevel: 3
  postbuild: "..\..\common\cc2540\cc254x_ubl_pp.bat" "$PROJ_DIR$" "ProdUBL" "CC2541DK-Sensor-OAD-ImgB\Exe\SensorTag.sim"
  XLINK.XclFile: ..\..\common\cc2540\cc254x_f256_imgB.xcl
configuration CC2541DK-Sensor-OAD-ImgA-Test (8051)
  as the first configuration, except:
  ICC8051.CCDefines: FEATURE_OAD_BIM; HAL_IMAGE_A; FEATURE_OAD; OAD_KEEP_NV_PAGES; INT_HEAP_LEN=3072; HALNODEBUG; OSAL_CBTIMER_NUM_TASKS=1; HAL_AES_DMA=TRUE; HAL_DMA=TRUE; POWER_SAVING; HAL_LCD=FALSE; HAL_LED=FALSE; HAL_KEY=TRUE; HAL_I2C=TRUE; HAL_ADC=FALSE; OAD_IMAGE_VERSION=6
  ICC8051.CCIncludePath2: as above
  ICC8051.CCOptLevel: 3
  XLINK.XclFile: ..\..\common\cc2540\cc254x_f256_imgA.xcl
  group APP
    ../Source/: OSAL_SensorTag.c SensorTag.c sensorTag.h SensorTag_Main.c
  group HAL/Common
    ../../../../Components/hal/common/: hal_drivers.c
  group HAL/Include
    ../../../../Components/hal/include/: hal_assert.h hal_board.h hal_defs.h hal_drivers.h hal_flash.h hal_key.h hal_lcd.h hal_led.h hal_sleep.h hal_timer.h hal_uart.h
    ../../../../Components/services/saddr/: saddr.h
  group HAL/Target/Config
    ../../../../Components/hal/target/CC2541ST/: hal_board_cfg.h
  group HAL/Target/Drivers
    ../../../../Components/hal/target/CC2541ST/: hal_acc.c hal_aes.c hal_assert.c hal_bar.c hal_crc.c hal_dma.c hal_flash.c hal_gyro.c hal_humi.c hal_i2c.c hal_interrupt.c hal_irtemp.c hal_keys.c hal_led.c hal_mag.c hal_sensor.c hal_sleep.c hal_startup.c hal_timer.c
  group HAL/Target/Includes
    ../../../../Components/hal/target/CC2541ST/: hal_acc.h hal_aes.h hal_bar.h hal_dma.h hal_gyro.h hal_humi.h hal_i2c.h hal_irtemp.h hal_keys.h hal_mag.h hal_mcu.h hal_sensor.h hal_types.h
  group LIB
    ../../Libraries/CC2541DB/bin/: CC2541_BLE_peri.lib
    ../../Libraries/Common/bin/: CC254x_BLE_HCI_TL_None.lib
  group OSAL
    ../../../../Components/ble/include/: bcomdef.h
    ../../../../Components/osal/common/: OSAL.c osal_bufmgr.c osal_cbtimer.c OSAL_ClockBLE.c OSAL_Memory.c OSAL_PwrMgr.c OSAL_Timers.c
    ../../../../Components/osal/mcu/cc2540/: osal_snv.c
  group PROFILES
    ../../Profiles/SensorProfile/CC254x/: accelerometerservice.c accelerometerservice.h barometerservice.c barometerservice.h ccservice.c ccservice.h gyroservice.c gyroservice.h humidityservice.c humidityservice.h irtempservice.c irtempservice.h magnetometerservice.c magnetometerservice.h st_util.c st_util.h testservice.c testservice.h
    ../Source/: devinfoservice-st.c devinfoservice-st.h
    ../../Profiles/Roles/: gap.c gapbondmgr.c gapbondmgr.h peripheral.h
    ../../Include/: gapgattserver.h gattservapp.h
    ../../../../Components/ble/host/: gatt_uuid.c
    ../../Profiles/GATT/: gattservapp_util.c
    ../../Profiles/OAD/: oad.h oad_target.c oad_target.h
    ../../Profiles/Roles/CC254x/: peripheral.c
    ../../Profiles/Keys/CC254x/: simplekeys.c
    ../../Profiles/Keys/: simplekeys.h
  group TOOLS
    ../../config/: buildComponents.cfg
    ./: buildConfig.cfg
    ../../common/cc2540/: OnBoard.c OnBoard.h
